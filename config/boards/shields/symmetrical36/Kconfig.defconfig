## config/boards/shields/symmetrical36/Kconfig.defconfig
```kconfig
if SHIELD_SYMMETRICAL36

config ZMK_KEYBOARD_NAME
    default "Symmetrical 36"

endif
```
